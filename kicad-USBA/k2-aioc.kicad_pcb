# Repository ArijitKHaldar/AIOC-USBA

## KiCad design kicad-USBA/k2-aioc.kicad_pcb

Parts:
C1, C2: 22p/NP0; C_0603_1608Metric; LCSC C1653
C3, C8, C9, C12, C15: 100n; C_0603_1608Metric; LCSC C14663
C4, C5, C6, C7, C10, C13, C14: 4.7u/10V/X5R; C_0603_1608Metric; LCSC C19666
C11: 10n/NP0; C_0603_1608Metric; LCSC C57112
D1: GREEN; LED_0603_1608Metric; LCSC C72043
D2: RED; LED_0603_1608Metric; LCSC C2286
D3, D4: N.M.; LED_0603_1608Metric; not fitted
FB1, FB2: 600R@100MHz; L_0603_1608Metric; LCSC C1002
H1, H2: ToolingHole; TOOLING-HOLE
J1: USB_A; USB_A_Molex_48037-2200_Horizontal; not fitted
J2: Conn_01x07_Male; PinHeader_1x07_P1.27mm_Vertical; not fitted
J3: 2.5mm; PinHeader_1x03_P1.27mm_Vertical; not fitted
J4: 3.5mm; PinHeader_1x03_P1.27mm_Vertical; not fitted
Q1: BC847BS; SOT-363_SC-70-6; LCSC C8653
R1: 1.5K; R_0603_1608Metric; LCSC C22843
R2: 10K; R_0603_1608Metric; LCSC C25804
R3, R16: 5.1K; R_0603_1608Metric; LCSC C23186
R4, R8, R9, R15: 220R; R_0603_1608Metric; LCSC C22962
R5, R10, R11, R14: 2.2K; R_0603_1608Metric; LCSC C4190
R12, R13: 22R; R_0603_1608Metric; LCSC C23345
R17: N.M.; R_0603_1608Metric; not fitted
U1: MIC5330-SSYML; Micrel_MLF-8-1EP_2x2mm_P0.5mm_EP0.6x1.2mm; LCSC C144168
U2: STM32F373CBTx; LQFP-48_7x7mm_P0.5mm; LCSC C94046
Y1: 8MHz/20pF; Crystal_SMD_5032-2Pin_5.0x3.2mm; LCSC C115962

Connections:
+3.3VA: C9.1, C10.1, FB1.1, R16.1, U2.9 (VDDA), U2.24 (VDDSD), U2.25 (VREFSD+)
+3V3: C4.1, C7.1, C8.1, J2.7, R1.1, U1.8 (VOUT1), U2.1 (VBAT), U2.17 (VDD), U2.36 (PF7), U2.48 (VDD)
/AFIN: C11.1, R3.2, R5.1, R16.2, U2.20 (PB2)
/AFOUT: R2.2, U2.14 (PA4)
/BOOT0: J2.1, R14.2, U2.44 (BOOT0)
/DAC_ATTEN: R17.2, U2.13 (PA3)
/NRST: C15.1, J2.3, U2.7 (NRST)
/OSCIN: C1.1, U2.5 (PF0), Y1.1
/OSCOUT: C2.1, U2.6 (PF1), Y1.2
/PTT1: R11.1, U2.11 (PA1)
/PTT2: R10.1, U2.10 (PA0)
/RADIO-MIC: C13.2, J4.2
/RADIO-RX-PTT1: J4.3, R8.1, R13.1
/RADIO-SPK: C14.2, J3.1
/RADIO-TX: J3.2, R9.1
/RADIO-VP-PTT2: J4.1, R12.1
/SWCLK: J2.6, U2.37 (PA14)
/SWDIO: J2.4, U2.34 (PA13)
/SWO: J2.2, U2.39 (PB3)
/USART-RX: R9.2, U2.31 (PA10)
/USART-TX: R8.2, U2.30 (PA9)
/USB-DN: J1.2 (D-), U2.32 (PA11)
/USB-DP: J1.3 (D+), R1.2, U2.33 (PA12)
/VBUS: FB2.2, J1.1 (VBUS)
/VIN: C6.1, FB2.1, U1.1 (VIN), U1.4 (EN2), U1.5 (EN1)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C15.2, J1.4 (GND), J1.5 (Shield), J2.5, J3.3, Q1.1 (E1), Q1.4 (E2), R3.1, R4.1, R14.1, U1.2 (GND), U1.9 (GND), U2.8 (VSSA), U2.23 (VSSSD), U2.35 (PF6), U2.47 (VSS)
unnamed: C12.1, C13.1, R2.1, R4.2, R17.1
unnamed: C14.1, R5.2
unnamed: D1.2 (A), D2.1 (K), D3.2 (A), D4.1 (K), U2.46 (PB9)
unnamed: D1.1 (K), D2.2 (A), D3.1 (K), D4.2 (A), R15.1
unnamed: Q1.2 (B1), R10.2
unnamed: Q1.6 (C1), R12.2
unnamed: Q1.5 (B2), R11.2
unnamed: Q1.3 (C2), R13.2
unnamed: C3.1, U1.3 (BYP)
unnamed: C5.1, FB1.2, U1.7 (VOUT2)
unnamed: R15.2, U2.45 (PB8)

Notes on the sheet:
STM Disco SWD Header
Short Pins for Bootloader
SDADC1_AIN4P/ADC2_IN12
USART1-TX
K connector consists of two TRS connectors (3.5mm and 2.5mm) spaced 12mm apart Upper connector (2.5mm) T: SPK+ R: TxData (from Radio) S: GND Lower connector (3.5mm) T: +V/PTT2 R: MIC+ S: PTT1/RxData (to Radio)
GPIOA P.P.
DAC1_OUT1
GPIOA O.D.
Compatible to STM32F302CBTx (no DS-ADC)
USART1-RX

Board: 2 copper layers, 21.6 x 31.8 mm, 46 parts (2 on the bottom side), 37 nets.

File kicad-USBA/production/bom.csv:

Comment	Designator	Footprint	LCSC	Quantity
22p/NP0	"C1, C2"	C_0603_1608Metric	C1653	2
4.7u/10V/X5R	"C10, C13, C14, C4, C5, C6, C7"	C_0603_1608Metric	C19666	7
10n/NP0	C11	C_0603_1608Metric	C57112	1
100n	"C12, C15, C3, C8, C9"	C_0603_1608Metric	C14663	5
GREEN	D1	LED_0603_1608Metric	C205450	1
RED	D2	LED_0603_1608Metric	C2286	1
600R@100MHz	"FB1, FB2"	L_0603_1608Metric	C1002	2
BC847BS	Q1	SOT-363_SC-70-6	C8653	1
1.5K	R1	R_0603_1608Metric	C22843	1
2.2K	"R10, R11, R14, R5"	R_0603_1608Metric	C4190	4
22R	"R12, R13"	R_0603_1608Metric	C23345	2
220R	"R15, R4, R8, R9"	R_0603_1608Metric	C22962	4
5.1K	"R16, R3"	R_0603_1608Metric	C23186	2
10K	R2	R_0603_1608Metric	C25804	1
MIC5330-SSYML	U1	Micrel_MLF-8-1EP_2x2mm_P0.5mm_EP0.6x1.2mm	C144168	1
STM32F373CBTx	U2	LQFP-48_7x7mm_P0.5mm	C94046	1
8MHz/20pF	Y1	Crystal_SMD_5032-2Pin_5.0x3.2mm	C115962	1

## Commit log

2024-08-04 Added option to have USB A instead of USB C
